# Keil uVision project FreeRtosBase.uvprojx, settings and files
target FreeRtosBase (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRtosBase
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\FreeRTOS\Source\include;..\Lib\STM32F10xFWLib\inc;..\..\FreeRtosBase;..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\Tasks\inc;..\Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ../System/: STM32F10x.s
    ../Lib/STM32F10xFWLib/src/: cortexm3_macro_rvds.s
  group Application
    ../Application/: main.c
  group FreeRTOS
    ../FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group STM32F103C8
    ../Lib/STM32F10xFWLib/src/: stm32f10x_systick.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c
  group Tasks
    ../Tasks/src/: LED_Task.c
  group Driver
    ../Driver/src/: Driver_I2C.c Driver_GPIO.c
software components: Device:Startup 1.0.0
