# Keil uVision project PowerMonitor.uvprojx, settings and files
target Target 1 (6090000::V6.9::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CPP_Base +hex
  c flags: Optim=6 uC99=1 uGnu=1 v6Lang=3 v6LangP=6 wLevel=3
  c include: ..\CPP_Base;.\CMSIS_Include;.\StdPeriph_Driver\inc;.\Drivers\inc;.\CPP_FW\inc;.\Devices\inc;.\Utils\inc;.\GUI\inc;.\Test\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./App/Src/: main.cpp
  group StdPeriph_Driver
    ./StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group Driver
    ./Drivers/src/: Gpio.cpp GpioInput.cpp GpioOutput.cpp I2c.cpp I2CDriver.cpp SpiDriver.cpp
  group CPP_FW
    ./CPP_FW/src/: ClockManager.cpp InterruptManager.cpp Peripheral.cpp PortManager.cpp SysTickTimer.cpp
  group Devices
    ./Devices/src/: DS3231.cpp HwButton.cpp HwButtonIntr.cpp INA219.cpp Led.cpp Nokia5110LCD.cpp
  group Utils
    ./Utils/src/: Queue.cpp
  group GUI
    ./GUI/src/: Line.cpp Menu.cpp Page.cpp Screen.cpp UI.cpp ControlScreen.cpp
  group Test
    ./Test/src/: Test.cpp
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
