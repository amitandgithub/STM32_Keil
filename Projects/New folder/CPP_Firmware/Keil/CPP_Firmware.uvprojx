# Keil uVision project CPP_Firmware.uvprojx, settings and files
target Target 1 (6090000::V6.9::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CPP_Firmware
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=6 v6Lto=1 wLevel=3
  c include: ..\System;..\STM32F10xFWLib\inc;..\HAL\inc;..\Test\inc;..\App\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../App/Src/: main.cpp
  group System
    ./RTE/Device/STM32F103C8/: startup_stm32f10x_md.s system_stm32f10x.c RTE_Device.h
  group STM32
    ../STM32F10xFWLib/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_i2c.c stm32f10x_spi.c
  group Test
    ../Test/src/: Test.cpp
  group Drivers
    ../HAL/src/: ClockManager.cpp ControlScreen.cpp DS3231.cpp Gpio.cpp GpioInput.cpp GpioOutput.cpp HwButton.cpp HwButtonIntr.cpp HwStopWatch.cpp I2c.cpp I2CDriver.cpp INA219.cpp InterruptManager.cpp Led.cpp Line.cpp Menu.cpp Nokia5110LCD.cpp Page.cpp Peripheral.cpp PortManager.cpp Queue.cpp Screen.cpp SpiDriver.cpp StopWatch.cpp SysTickTimer.cpp Time.cpp UI.cpp
